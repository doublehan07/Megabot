# Keil uVision project project-rec.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: project-ini
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER, STM32F10X_MD, HSE_VALUE = 12000000, MyID = 0x01
  c include: ..\STM32F10x_StdPeriph_Driver\inc;..\Decadriver;..\Platform;..\Dwm1000;..\User_rec;..\Strategy
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group StartUp
    ./: startup_stm32f10x_md.s
  group STM32F1Lib
    ../STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c
  group User
    ../User_rec/: main.c
  group Platform
    ../Platform/: deca_mutex.c deca_sleep.c deca_spi.c port.c stm32f10x_it.c system_stm32f10x.c
  group Decadriver
    ../Decadriver/: deca_device.c deca_params_init.c deca_range_tables.c
  group Dwm1000
    ../Dwm1000/: dwm1000_port.c ranging_interface.c initiator.c receptor.c demo_api.c usart2.c
  group Strategy
    ../Strategy/: FourCars.c
