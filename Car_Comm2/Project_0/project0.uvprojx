# Keil uVision project project0.uvprojx, settings and files
target Target 1 (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: project-ini
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER, STM32F10X_MD, HSE_VALUE = 12000000, MyID = 0x00
  c include: ..\STM32F10x_StdPeriph_Driver\inc;..\Decadriver;..\Platform;..\Dwm1000;..\User;..\Strategy
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group StartUp
    ./: startup_stm32f10x_md.s
  group STM32F1Lib
    ../STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c
  group User
    ../User/: main.c
  group Platform
    ../Platform/: deca_mutex.c deca_sleep.c deca_spi.c port.c stm32f10x_it.c system_stm32f10x.c
  group Decadriver
    ../Decadriver/: deca_device.c deca_params_init.c deca_range_tables.c
  group Dwm1000
    ../Dwm1000/: dwm1000_port.c ranging_interface.c initiator.c receptor.c usart2.c
  group Strategy
    ../Strategy/: Communication.c Communication.h
software components: CMSIS:CORE 4.3.0
