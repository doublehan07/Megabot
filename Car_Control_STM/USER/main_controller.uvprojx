# Keil uVision project main_controller.uvprojx, settings and files
target main_controller (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IROM(0x08000000,0x40000) IRAM(0x20000000,0xC000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: main_controller +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_HD, USE_STDPERIPH_DRIVER, CAR_2
  c include: ..\FWLIB\inc;..\FWLIB\src;..\CMSIS;..\SRC
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group STARTCODE
    ../CMSIS/startup/: startup_stm32f10x_hd.s
  group FWLIB
    ../FWLIB/src/: misc.c stm32f10x_exti.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_tim.c stm32f10x_usart.c
  group CMSIS
    ../CMSIS/: core_cm3.c system_stm32f10x.c
  group SRC
    ../SRC/: main.c stm32f10x_conf.h stm32f10x_it.c stm32f10x_it.h port.h main.h init.c init.h motor_control.c motor_control.h encoder.c encoder.h imu.c imu.h wx_comm.c wx_comm.h bt_comm.c bt_comm.h
