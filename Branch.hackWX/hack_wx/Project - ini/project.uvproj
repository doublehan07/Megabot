# Keil uVision project project.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: project
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER, STM32F10X_MD, MyID = 0x00
  c include: ..\STM32F10x_StdPeriph_Driver\inc;..\decadriver;..\Platform;..\Dwm1000;..\User;..\Strategy
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group StartUp
    ./: startup_stm32f10x_md.s
  group STM32F1Lib
    ../STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c
  group USER
    ../User/: main.c
  group Platform
    ../platform/: port.c
    ../Platform/: deca_mutex.c deca_sleep.c deca_spi.c stm32f10x_it.c system_stm32f10x.c
  group DecaDriver
    ../decadriver/: deca_device.c deca_params_init.c deca_range_tables.c
  group Dwm1000
    ../Dwm1000/: dwm1000_port.c ranging_interface_old.c ranging_interface.c ranging_template_1to1.c
  group Strategy
    ../Strategy/: FourCars.c
