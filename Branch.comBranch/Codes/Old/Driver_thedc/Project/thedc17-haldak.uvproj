# Keil uVision project thedc17-haldak.uvproj, settings and files
target thedc17-haldak (ARM-ADS)
  device: STM32F407VE STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: thedc17-haldak
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER, __FPU_USED = 1, ARM_MATH_CM4, __FPU_PRESENT = 1, STM32F40_41xxx
  c include: ..\Platform;..\STM32F4xx_StdPeriph_Driver\inc;..\User
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Startup
    ./: startup_stm32f40_41xxx.s
  group User
    ../User/: main.c Init.c stm32f4xx_it.c Motor.c
  group Platform
    ../Platform/: system_stm32f4xx.c stm32f4xx.h stm32f4xx_conf.h system_stm32f4xx.h
  group STM32F4LIB
    ../STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_flash.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_tim.c
