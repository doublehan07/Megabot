# Keil uVision project TEST.uvprojx, settings and files
target TEST (ARM-ADS)
  device: STM32F405RG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.4.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: TEST +hex
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER,STM32F40XX, ARM_MATH_CM4
  c misc: --c99
  c include: .\CMSIS;.\CMSIS\Include;.\Lib\inc;.\Startup;.\User;D:\MDKV5\ARM\Pack\ARM\CMSIS\4.2.0\CMSIS\Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group User
    ./User/: main.c stm32f4xx_it.c delay.c usart1.c spi.c printf.c max21100.c
  group Lib
    ./Lib/src/: misc.c stm32f4xx_tim.c stm32f4xx_rcc.c stm32f4xx_gpio.c stm32f4xx_usart.c stm32f4xx_spi.c stm32f4xx_exti.c stm32f4xx_adc.c stm32f4xx_syscfg.c stm32f4xx_dma.c stm32f4xx_flash.c
  group CMSIS
    ./CMSIS/: system_stm32f4xx.c
  group Startup
    ./Startup/: startup_stm32f40xx.s
