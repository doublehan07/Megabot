# Keil uVision project example.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F303VC STMicroelectronics
  pack: Keil.STM32F3xx_DFP.1.3.0
  cpu: IROM(0x08000000,0x00040000) IRAM(0x20000000,0x0000C000) IRAM2(0x10000000,0x00002000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: example +hex
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c include: .\fis_driver;.\src\stdperiph_driver\inc;.\src\stdperiph_driver;.\src;C:\Keil_v5\ARM\Pack\ARM\CMSIS\4.4.0\CMSIS\Include
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xffff
  memory RVCT10: RAM 0x10000000 size 0x2000
  group fis_driver
    ./fis_driver/: fis1100_driver.c
  group src
    ./src/: main.c
    ./src/stdperiph_driver/: stm32f30x_it.c
  group std_peripheral
    ./src/stdperiph_driver/src/: stm32f30x_dma.c stm32f30x_exti.c stm32f30x_gpio.c stm32f30x_rcc.c stm32f30x_spi.c stm32f30x_syscfg.c stm32f30x_misc.c stm32f30x_usart.c
software components: CMSIS:CORE 4.2.0, CMSIS:DSP 1.4.6, Device:Startup 1.3.0
