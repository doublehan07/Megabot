# Keil uVision project project.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32F401RE STMicroelectronics
  cpu: IRAM(0x20000000-0x20017FFF) IROM(0x08000000-0x0805FFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: project
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER,__FPU_PRESENT = 1,__FPU_USED = 1
  c include: ..\STM32F4xx_StdPeriph_Driver\inc;..\System;..\User;..\Decadriver
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x60000
  memory RVCT9: RAM 0x20000000 size 0x18000
  group StartUp
    ./: startup_stm32f401xx.s
  group System
    ../System/: stm32f4xx_it.c system_stm32f4xx.c
  group STM32F4Lib
    ../STM32F4xx_StdPeriph_Driver/src/: stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_tim.c stm32f4xx_flash.c misc.c stm32f4xx_spi.c
  group USER
    ../User/: main.c Init.c
  group Decadriver
    ../Decadriver/: deca_device.c deca_params_init.c deca_range_tables.c deca_sleep.c port.c lcd.c
