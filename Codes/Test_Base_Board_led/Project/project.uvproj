# Keil uVision project project.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32F407ZG STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: project
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER, __FPU_USED = 1, ARM_MATH_CM4, __FPU_PRESENT = 1, HSE_VALUE = 8000000
  c include: ..\STM32F4xx_StdPeriph_Driver\inc;..\User;..\decadriver;..\platform;..\Dwm1000
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group StartUp
    ./: startup_stm32f40_41xxx.s
  group STM32F4Lib
    ../STM32F4xx_StdPeriph_Driver/src/: stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_tim.c stm32f4xx_flash.c misc.c stm32f4xx_spi.c stm32f4xx_exti.c stm32f4xx_rtc.c stm32f4xx_syscfg.c stm32f4xx_usart.c
  group USER
    ../User/: main.c
  group Platform
    ../platform/: port.c stm32f4xx_it.c system_stm32f4xx.c
    ../Platform/: deca_mutex.c deca_sleep.c deca_spi.c
  group DecaDriver
    ../decadriver/: deca_device.c deca_params_init.c deca_range_tables.c
  group Dwm1000
    ../Dwm1000/: dwm1000_port.c
