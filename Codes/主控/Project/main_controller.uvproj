# Keil uVision project main_controller.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32F407ZG STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: main_controller
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER,__FPU_USED = 1,ARM_MATH_CM4,__FPU_PRESENT = 1,HSE_VALUE = 8000000,STM32F40_41xxx
  c include: ..\STM32F4xx_StdPeriph_Driver\inc;..\User;..\platform;..\Motor;..\JY-901;..\Strategy
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group StartUp
    ./: startup_stm32f40_41xxx.s
  group STM32F4Lib
    ../STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_rcc.c stm32f4xx_flash.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_gpio.c stm32f4xx_adc.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_syscfg.c
  group USER
    ../User/: main.c
  group Platform
    ../platform/: port.c stm32f4xx_it.c system_stm32f4xx.c
  group Motor
    ../Motor/: ADC.c motor_ctr.c PWM.C MovementCtr.c
  group JY-901
    ../JY-901/: JY901.c
  group Strategy
    ../Strategy/: leader_nodes.c ordinary_nodes.c triangle_nodes.c strategy.c
