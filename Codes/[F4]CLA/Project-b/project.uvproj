# Keil uVision project project.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32F401RE STMicroelectronics
  cpu: IRAM(0x20000000-0x20017FFF) IROM(0x08000000-0x0805FFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: project
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER, __FPU_USED = 1, ARM_MATH_CM4, __FPU_PRESENT = 1, MyID = 0x01
  c include: ..\STM32F4xx_StdPeriph_Driver\inc;..\decadriver;..\platform;..\Dwm1000;..\User-a;..\Strategy
  memory RVCT4: ROM 0x8000000 size 0x60000
  memory RVCT9: RAM 0x20000000 size 0x18000
  group StartUp
    ./: startup_stm32f40_41xxx.s
  group STM32F4Lib
    ../STM32F4xx_StdPeriph_Driver/src/: stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_tim.c stm32f4xx_flash.c misc.c stm32f4xx_spi.c stm32f4xx_exti.c stm32f4xx_rtc.c stm32f4xx_syscfg.c stm32f4xx_usart.c
  group USER
    ../User-a/: main.c
  group Platform
    ../platform/: port.c stm32f4xx_it.c system_stm32f4xx.c
    ../Platform/: deca_mutex.c deca_sleep.c deca_spi.c
  group DecaDriver
    ../decadriver/: deca_device.c deca_params_init.c deca_range_tables.c
  group Dwm1000
    ../Dwm1000/: dwm1000_port.c ranging_interface.c ranging_template_1to1.c
  group Strategy
    ../Strategy/: ccommtest.c Commtest.c newStrategy.c
